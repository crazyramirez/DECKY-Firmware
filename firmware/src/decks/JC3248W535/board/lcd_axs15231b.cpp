// AXS15231B QSPI panel driver for the Guition JC3248W535.
//
// Init tables and QSPI opcode framing derived from (Apache-2.0):
//   - Espressif esp_lcd_axs15231b (as vendored in GthiN89/JC3248W535EN)
//   - GlomarGadaffi/jc3248-display-driver (tsebelev-verified JC3248W535EN table)
// Re-written here as a small C++ module so we own the flush path and can select the
// table at build time (PCD_LCD_INIT_TABLE) during hardware validation.

#include "lcd_axs15231b.h"

#include <string.h>

#include "board_pins.h"
#include "driver/spi_master.h"
#include "esp_check.h"
#include "esp_heap_caps.h"
#include "esp_lcd_panel_io.h"
#include "esp_log.h"
#include "esp_timer.h"
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"
#include "freertos/task.h"

namespace lcd {
namespace {

const char *TAG = "lcd";

constexpr uint32_t kOpWriteCmd = 0x02;
constexpr uint32_t kOpWriteColor = 0x32;
constexpr int kCmdSwReset = 0x01;
constexpr int kCmdSlpOut = 0x11;
constexpr int kCmdDispOff = 0x28;
constexpr int kCmdDispOn = 0x29;
constexpr int kCmdCaset = 0x2A;
constexpr int kCmdRamWr = 0x2C;
constexpr int kCmdRamWrC = 0x3C;
constexpr int kCmdMadctl = 0x36;
constexpr int kCmdColmod = 0x3A;

constexpr int kBandRows = 32;  // 480 / 32 = 15 bands
constexpr int kBands = PCD_LCD_V_RES / kBandRows;
constexpr size_t kBandPixels = PCD_LCD_H_RES * kBandRows;
constexpr size_t kBandBytes = kBandPixels * sizeof(uint16_t);
static_assert(PCD_LCD_V_RES % kBandRows == 0, "band rows must divide the panel height");

struct InitCmd {
  uint8_t cmd;
  uint8_t len;
  uint16_t delay_ms;
  uint8_t data[31];
};

#if PCD_LCD_INIT_TABLE == 1
// tsebelev / GlomarGadaffi verified JC3248W535EN table. Ends by setting the 320x480 window.
const InitCmd kInit[] = {
    {0xBB, 8, 0, {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5A, 0xA5}},
    {0xA0, 17, 0, {0xC0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x04, 0x3F, 0x20, 0x05, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00}},
    {0xA2, 31, 0, {0x30, 0x3C, 0x24, 0x14, 0xD0, 0x20, 0xFF, 0xE0, 0x40, 0x19, 0x80, 0x80, 0x80, 0x20, 0xf9, 0x10,
                   0x02, 0xff, 0xff, 0xF0, 0x90, 0x01, 0x32, 0xA0, 0x91, 0xE0, 0x20, 0x7F, 0xFF, 0x00, 0x5A}},
    {0xD0, 30, 0, {0xE0, 0x40, 0x51, 0x24, 0x08, 0x05, 0x10, 0x01, 0x20, 0x15, 0x42, 0xC2, 0x22, 0x22, 0xAA,
                   0x03, 0x10, 0x12, 0x60, 0x14, 0x1E, 0x51, 0x15, 0x00, 0x8A, 0x20, 0x00, 0x03, 0x3A, 0x12}},
    {0xA3, 22, 0, {0xA0, 0x06, 0xAa, 0x00, 0x08, 0x02, 0x0A, 0x04, 0x04, 0x04, 0x04,
                   0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x55, 0x55}},
    {0xC1, 30, 0, {0x31, 0x04, 0x02, 0x02, 0x71, 0x05, 0x24, 0x55, 0x02, 0x00, 0x41, 0x00, 0x53, 0xFF, 0xFF,
                   0xFF, 0x4F, 0x52, 0x00, 0x4F, 0x52, 0x00, 0x45, 0x3B, 0x0B, 0x02, 0x0d, 0x00, 0xFF, 0x40}},
    {0xC3, 11, 0, {0x00, 0x00, 0x00, 0x50, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01}},
    {0xC4, 29, 0, {0x00, 0x24, 0x33, 0x80, 0x00, 0xea, 0x64, 0x32, 0xC8, 0x64, 0xC8, 0x32, 0x90, 0x90, 0x11,
                   0x06, 0xDC, 0xFA, 0x00, 0x00, 0x80, 0xFE, 0x10, 0x10, 0x00, 0x0A, 0x0A, 0x44, 0x50}},
    {0xC5, 23, 0, {0x18, 0x00, 0x00, 0x03, 0xFE, 0x3A, 0x4A, 0x20, 0x30, 0x10, 0x88, 0xDE,
                   0x0D, 0x08, 0x0F, 0x0F, 0x01, 0x3A, 0x4A, 0x20, 0x10, 0x10, 0x00}},
    {0xC6, 20, 0, {0x05, 0x0A, 0x05, 0x0A, 0x00, 0xE0, 0x2E, 0x0B, 0x12, 0x22,
                   0x12, 0x22, 0x01, 0x03, 0x00, 0x3F, 0x6A, 0x18, 0xC8, 0x22}},
    {0xC7, 20, 0, {0x50, 0x32, 0x28, 0x00, 0xa2, 0x80, 0x8f, 0x00, 0x80, 0xff,
                   0x07, 0x11, 0x9c, 0x67, 0xff, 0x24, 0x0c, 0x0d, 0x0e, 0x0f}},
    {0xC9, 4, 0, {0x33, 0x44, 0x44, 0x01}},
    {0xCF, 27, 0, {0x2C, 0x1E, 0x88, 0x58, 0x13, 0x18, 0x56, 0x18, 0x1E, 0x68, 0x88, 0x00, 0x65, 0x09,
                   0x22, 0xC4, 0x0C, 0x77, 0x22, 0x44, 0xAA, 0x55, 0x08, 0x08, 0x12, 0xA0, 0x08}},
    {0xD5, 30, 0, {0x40, 0x8E, 0x8D, 0x01, 0x35, 0x04, 0x92, 0x74, 0x04, 0x92, 0x74, 0x04, 0x08, 0x6A, 0x04,
                   0x46, 0x03, 0x03, 0x03, 0x03, 0x82, 0x01, 0x03, 0x00, 0xE0, 0x51, 0xA1, 0x00, 0x00, 0x00}},
    {0xD6, 30, 0, {0x10, 0x32, 0x54, 0x76, 0x98, 0xBA, 0xDC, 0xFE, 0x93, 0x00, 0x01, 0x83, 0x07, 0x07, 0x00,
                   0x07, 0x07, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x00, 0x84, 0x00, 0x20, 0x01, 0x00}},
    {0xD7, 19, 0, {0x03, 0x01, 0x0b, 0x09, 0x0f, 0x0d, 0x1E, 0x1F, 0x18, 0x1d,
                   0x1f, 0x19, 0x40, 0x8E, 0x04, 0x00, 0x20, 0xA0, 0x1F}},
    {0xD8, 12, 0, {0x02, 0x00, 0x0a, 0x08, 0x0e, 0x0c, 0x1E, 0x1F, 0x18, 0x1d, 0x1f, 0x19}},
    {0xD9, 12, 0, {0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F}},
    {0xDD, 12, 0, {0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F}},
    {0xDF, 8, 0, {0x44, 0x73, 0x4B, 0x69, 0x00, 0x0A, 0x02, 0x90}},
    {0xE0, 17, 0, {0x3B, 0x28, 0x10, 0x16, 0x0c, 0x06, 0x11, 0x28, 0x5c, 0x21, 0x0D, 0x35, 0x13, 0x2C, 0x33, 0x28, 0x0D}},
    {0xE1, 17, 0, {0x37, 0x28, 0x10, 0x16, 0x0b, 0x06, 0x11, 0x28, 0x5C, 0x21, 0x0D, 0x35, 0x14, 0x2C, 0x33, 0x28, 0x0F}},
    {0xE2, 17, 0, {0x3B, 0x07, 0x12, 0x18, 0x0E, 0x0D, 0x17, 0x35, 0x44, 0x32, 0x0C, 0x14, 0x14, 0x36, 0x3A, 0x2F, 0x0D}},
    {0xE3, 17, 0, {0x37, 0x07, 0x12, 0x18, 0x0E, 0x0D, 0x17, 0x35, 0x44, 0x32, 0x0C, 0x14, 0x14, 0x36, 0x32, 0x2F, 0x0F}},
    {0xE4, 17, 0, {0x3B, 0x07, 0x12, 0x18, 0x0E, 0x0D, 0x17, 0x39, 0x44, 0x2E, 0x0C, 0x14, 0x14, 0x36, 0x3A, 0x2F, 0x0D}},
    {0xE5, 17, 0, {0x37, 0x07, 0x12, 0x18, 0x0E, 0x0D, 0x17, 0x39, 0x44, 0x2E, 0x0C, 0x14, 0x14, 0x36, 0x3A, 0x2F, 0x0F}},
    {0xA4, 16, 0, {0x85, 0x85, 0x95, 0x82, 0xAF, 0xAA, 0xAA, 0x80, 0x10, 0x30, 0x40, 0x40, 0x20, 0xFF, 0x60, 0x30}},
    {0xA4, 4, 0, {0x85, 0x85, 0x95, 0x85}},
    {0xBB, 8, 0, {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}},
    {0x13, 0, 0, {}},                         // NORON
    {0x11, 0, 120, {}},                       // SLPOUT
    {0x35, 1, 0, {0x00}},                     // TEON (v-blank)
    {0x2C, 4, 0, {0x00, 0x00, 0x00, 0x00}},
    {0x2A, 4, 0, {0x00, 0x00, 0x01, 0x3f}},  // CASET 0..319
    {0x2B, 4, 0, {0x00, 0x00, 0x01, 0xdf}},  // RASET 0..479
};
#elif PCD_LCD_INIT_TABLE == 2
// Espressif esp_lcd_axs15231b default table (GthiN89 repo).
const InitCmd kInit[] = {
    {0xBB, 8, 0, {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5A, 0xA5}},
    {0xA0, 17, 0, {0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x64, 0x3F, 0x20, 0x05, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00}},
    {0xA2, 31, 0, {0x30, 0x04, 0x0A, 0x3C, 0xEC, 0x54, 0xC4, 0x30, 0xAC, 0x28, 0x7F, 0x7F, 0x7F, 0x20, 0xF8, 0x10,
                   0x02, 0xFF, 0xFF, 0xF0, 0x90, 0x01, 0x32, 0xA0, 0x91, 0xC0, 0x20, 0x7F, 0xFF, 0x00, 0x54}},
    {0xD0, 30, 0, {0x30, 0xAC, 0x21, 0x24, 0x08, 0x09, 0x10, 0x01, 0xAA, 0x14, 0xC2, 0x00, 0x22, 0x22, 0xAA,
                   0x03, 0x10, 0x12, 0x40, 0x14, 0x1E, 0x51, 0x15, 0x00, 0x40, 0x10, 0x00, 0x03, 0x3D, 0x12}},
    {0xA3, 22, 0, {0xA0, 0x06, 0xAA, 0x08, 0x08, 0x02, 0x0A, 0x04, 0x04, 0x04, 0x04,
                   0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x55, 0x55}},
    {0xC1, 30, 0, {0x33, 0x04, 0x02, 0x02, 0x71, 0x05, 0x24, 0x55, 0x02, 0x00, 0x41, 0x00, 0x53, 0xFF, 0xFF,
                   0xFF, 0x4F, 0x52, 0x00, 0x4F, 0x52, 0x00, 0x45, 0x3B, 0x0B, 0x02, 0x0D, 0x00, 0xFF, 0x40}},
    {0xC3, 11, 0, {0x00, 0x00, 0x00, 0x50, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01}},
    {0xC4, 29, 0, {0x00, 0x24, 0x33, 0x90, 0x50, 0xea, 0x64, 0x32, 0xC8, 0x64, 0xC8, 0x32, 0x90, 0x90, 0x11,
                   0x06, 0xDC, 0xFA, 0x04, 0x03, 0x80, 0xFE, 0x10, 0x10, 0x00, 0x0A, 0x0A, 0x44, 0x50}},
    {0xC5, 23, 0, {0x18, 0x00, 0x00, 0x03, 0xFE, 0x78, 0x33, 0x20, 0x30, 0x10, 0x88, 0xDE,
                   0x0D, 0x08, 0x0F, 0x0F, 0x01, 0x78, 0x33, 0x20, 0x10, 0x10, 0x80}},
    {0xC6, 20, 0, {0x05, 0x0A, 0x05, 0x0A, 0x00, 0xE0, 0x2E, 0x0B, 0x12, 0x22,
                   0x12, 0x22, 0x01, 0x00, 0x00, 0x3F, 0x6A, 0x18, 0xC8, 0x22}},
    {0xC7, 20, 0, {0x50, 0x32, 0x28, 0x00, 0xa2, 0x80, 0x8f, 0x00, 0x80, 0xff,
                   0x07, 0x11, 0x9F, 0x6f, 0xff, 0x26, 0x0c, 0x0d, 0x0e, 0x0f}},
    {0xC9, 4, 0, {0x33, 0x44, 0x44, 0x01}},
    {0xCF, 27, 0, {0x34, 0x1E, 0x88, 0x58, 0x13, 0x18, 0x56, 0x18, 0x1E, 0x68, 0xF7, 0x00, 0x65, 0x0C,
                   0x22, 0xC4, 0x0C, 0x77, 0x22, 0x44, 0xAA, 0x55, 0x04, 0x04, 0x12, 0xA0, 0x08}},
    {0xD5, 30, 0, {0x3E, 0x3E, 0x88, 0x00, 0x44, 0x04, 0x78, 0x33, 0x20, 0x78, 0x33, 0x20, 0x04, 0x28, 0xD3,
                   0x47, 0x03, 0x03, 0x03, 0x03, 0x86, 0x00, 0x00, 0x00, 0x30, 0x52, 0x3f, 0x40, 0x40, 0x96}},
    {0xD6, 30, 0, {0x10, 0x32, 0x54, 0x76, 0x98, 0xBA, 0xDC, 0xFE, 0x95, 0x00, 0x01, 0x83, 0x75, 0x36, 0x20,
                   0x75, 0x36, 0x20, 0x3F, 0x03, 0x03, 0x03, 0x10, 0x10, 0x00, 0x04, 0x51, 0x20, 0x01, 0x00}},
    {0xD7, 19, 0, {0x0a, 0x08, 0x0e, 0x0c, 0x1E, 0x18, 0x19, 0x1F, 0x00, 0x1F,
                   0x1A, 0x1F, 0x3E, 0x3E, 0x04, 0x00, 0x1F, 0x1F, 0x1F}},
    {0xD8, 12, 0, {0x0B, 0x09, 0x0F, 0x0D, 0x1E, 0x18, 0x19, 0x1F, 0x01, 0x1F, 0x1A, 0x1F}},
    {0xD9, 13, 0, {0x00, 0x0D, 0x0F, 0x09, 0x0B, 0x1F, 0x18, 0x19, 0x1F, 0x01, 0x1E, 0x1A, 0x1F}},
    {0xDD, 12, 0, {0x0C, 0x0E, 0x08, 0x0A, 0x1F, 0x18, 0x19, 0x1F, 0x00, 0x1E, 0x1A, 0x1F}},
    {0xDF, 8, 0, {0x44, 0x73, 0x4B, 0x69, 0x00, 0x0A, 0x02, 0x90}},
    {0xE0, 17, 0, {0x19, 0x20, 0x0A, 0x13, 0x0E, 0x09, 0x12, 0x28, 0xD4, 0x24, 0x0C, 0x35, 0x13, 0x31, 0x36, 0x2f, 0x03}},
    {0xE1, 17, 0, {0x38, 0x20, 0x09, 0x12, 0x0E, 0x08, 0x12, 0x28, 0xC5, 0x24, 0x0C, 0x34, 0x12, 0x31, 0x36, 0x2f, 0x27}},
    {0xE2, 17, 0, {0x19, 0x20, 0x0A, 0x11, 0x09, 0x06, 0x11, 0x25, 0xD4, 0x22, 0x0B, 0x33, 0x12, 0x2D, 0x32, 0x2f, 0x03}},
    {0xE3, 17, 0, {0x38, 0x20, 0x0A, 0x11, 0x09, 0x06, 0x11, 0x25, 0xC4, 0x21, 0x0A, 0x32, 0x11, 0x2C, 0x32, 0x2f, 0x27}},
    {0xE4, 17, 0, {0x19, 0x20, 0x0D, 0x14, 0x0D, 0x08, 0x12, 0x2A, 0xD4, 0x26, 0x0E, 0x35, 0x13, 0x34, 0x39, 0x2f, 0x03}},
    {0xE5, 17, 0, {0x38, 0x20, 0x0D, 0x13, 0x0D, 0x07, 0x12, 0x29, 0xC4, 0x25, 0x0D, 0x35, 0x12, 0x33, 0x39, 0x2f, 0x27}},
    {0xBB, 8, 0, {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}},
    {0x13, 0, 0, {}},
    {0x11, 0, 200, {}},
    {0x2C, 4, 0, {0x00, 0x00, 0x00, 0x00}},
    {0x2A, 4, 0, {0x00, 0x00, 0x01, 0x3f}},
    {0x2B, 4, 0, {0x00, 0x00, 0x01, 0xdf}},
};
#else
#error "PCD_LCD_INIT_TABLE must be 1 or 2"
#endif

esp_lcd_panel_io_handle_t s_io = nullptr;
uint16_t *s_bounce[2] = {nullptr, nullptr};
SemaphoreHandle_t s_done = nullptr;  // counting: one give per finished colour transfer
uint32_t s_last_push_us = 0;

bool IRAM_ATTR on_color_done(esp_lcd_panel_io_handle_t, esp_lcd_panel_io_event_data_t *, void *) {
  BaseType_t hp = pdFALSE;
  xSemaphoreGiveFromISR(s_done, &hp);
  return hp == pdTRUE;
}

esp_err_t tx_param(int cmd, const void *data, size_t len) {
  const int lcd_cmd = static_cast<int>((kOpWriteCmd << 24) | ((cmd & 0xFF) << 8));
  return esp_lcd_panel_io_tx_param(s_io, lcd_cmd, data, len);
}

esp_err_t tx_color(int cmd, const void *data, size_t len) {
  const int lcd_cmd = static_cast<int>((kOpWriteColor << 24) | ((cmd & 0xFF) << 8));
  return esp_lcd_panel_io_tx_color(s_io, lcd_cmd, data, len);
}

}  // namespace

esp_err_t init() {
  ESP_LOGI(TAG, "init: QSPI %d MHz, init table %d", PCD_LCD_PCLK_HZ / 1000000, PCD_LCD_INIT_TABLE);

  s_done = xSemaphoreCreateCounting(2, 0);
  for (auto &b : s_bounce) {
    b = static_cast<uint16_t *>(heap_caps_malloc(kBandBytes, MALLOC_CAP_DMA | MALLOC_CAP_INTERNAL));
  }
  if (!s_done || !s_bounce[0] || !s_bounce[1]) {
    ESP_LOGE(TAG, "bounce buffer alloc failed (%u B internal DMA each)", (unsigned)kBandBytes);
    return ESP_ERR_NO_MEM;
  }

  spi_bus_config_t bus = {};
  bus.sclk_io_num = PCD_PIN_LCD_SCK;
  bus.data0_io_num = PCD_PIN_LCD_D0;
  bus.data1_io_num = PCD_PIN_LCD_D1;
  bus.data2_io_num = PCD_PIN_LCD_D2;
  bus.data3_io_num = PCD_PIN_LCD_D3;
  bus.data4_io_num = -1;
  bus.data5_io_num = -1;
  bus.data6_io_num = -1;
  bus.data7_io_num = -1;
  bus.max_transfer_sz = kBandBytes;
  bus.flags = SPICOMMON_BUSFLAG_MASTER | SPICOMMON_BUSFLAG_QUAD;
  esp_err_t err = spi_bus_initialize(SPI2_HOST, &bus, SPI_DMA_CH_AUTO);
  if (err != ESP_OK) {
    ESP_LOGE(TAG, "spi_bus_initialize: %s", esp_err_to_name(err));
    return err;
  }

  esp_lcd_panel_io_spi_config_t io = {};
  io.cs_gpio_num = PCD_PIN_LCD_CS;
  io.dc_gpio_num = -1;
  io.spi_mode = 3;
  io.pclk_hz = PCD_LCD_PCLK_HZ;
  io.trans_queue_depth = 4;
  io.on_color_trans_done = on_color_done;
  io.user_ctx = nullptr;
  io.lcd_cmd_bits = 32;
  io.lcd_param_bits = 8;
  io.flags.quad_mode = 1;
  err = esp_lcd_new_panel_io_spi(static_cast<esp_lcd_spi_bus_handle_t>(SPI2_HOST), &io, &s_io);
  if (err != ESP_OK) {
    ESP_LOGE(TAG, "esp_lcd_new_panel_io_spi: %s", esp_err_to_name(err));
    return err;
  }

  // Software reset (RST is not wired), then sleep-out, orientation and pixel format.
  ESP_RETURN_ON_ERROR(tx_param(kCmdSwReset, nullptr, 0), TAG, "SWRESET");
  vTaskDelay(pdMS_TO_TICKS(120));
  ESP_RETURN_ON_ERROR(tx_param(kCmdSlpOut, nullptr, 0), TAG, "SLPOUT");
  vTaskDelay(pdMS_TO_TICKS(100));
  const uint8_t madctl = 0x00;  // native portrait, RGB order
  const uint8_t colmod = 0x55;  // 16 bpp
  ESP_RETURN_ON_ERROR(tx_param(kCmdMadctl, &madctl, 1), TAG, "MADCTL");
  ESP_RETURN_ON_ERROR(tx_param(kCmdColmod, &colmod, 1), TAG, "COLMOD");

  for (const InitCmd &c : kInit) {
    ESP_RETURN_ON_ERROR(tx_param(c.cmd, c.len ? c.data : nullptr, c.len), TAG, "init cmd 0x%02X", c.cmd);
    if (c.delay_ms) vTaskDelay(pdMS_TO_TICKS(c.delay_ms));
  }

  // The init tables do not leave the output stage on: DISPON is mandatory (black-but-backlit otherwise).
  ESP_RETURN_ON_ERROR(set_display_on(true), TAG, "DISPON");
  ESP_LOGI(TAG, "panel ready (%dx%d, %d bands of %d rows)", PCD_LCD_H_RES, PCD_LCD_V_RES, kBands, kBandRows);
  return ESP_OK;
}

esp_err_t set_display_on(bool on) {
  if (!s_io) return ESP_ERR_INVALID_STATE;
  return tx_param(on ? kCmdDispOn : kCmdDispOff, nullptr, 0);
}

esp_err_t sleep_in() {
  if (!s_io) return ESP_ERR_INVALID_STATE;
  tx_param(kCmdDispOff, nullptr, 0);
  const esp_err_t err = tx_param(0x10, nullptr, 0);  // SLPIN
  vTaskDelay(pdMS_TO_TICKS(120));
  return err;
}

esp_err_t push_frame(const uint16_t *fb) {
  if (!s_io || !fb) return ESP_ERR_INVALID_STATE;
  const int64_t t0 = esp_timer_get_time();

  // Full-width column window (cheap: only a param write).
  const uint8_t caset[4] = {0x00, 0x00, (PCD_LCD_H_RES - 1) >> 8, (PCD_LCD_H_RES - 1) & 0xFF};
  esp_err_t err = tx_param(kCmdCaset, caset, sizeof(caset));
  if (err != ESP_OK) return err;

  int inflight = 0;
  for (int band = 0; band < kBands; band++) {
    if (inflight == 2) {  // transfers finish in FIFO order: one give frees the oldest buffer
      xSemaphoreTake(s_done, portMAX_DELAY);
      inflight--;
    }
    uint16_t *buf = s_bounce[band & 1];
    memcpy(buf, fb + band * kBandPixels, kBandBytes);
    err = tx_color(band == 0 ? kCmdRamWr : kCmdRamWrC, buf, kBandBytes);
    if (err != ESP_OK) break;
    inflight++;
  }
  while (inflight > 0) {
    xSemaphoreTake(s_done, portMAX_DELAY);
    inflight--;
  }
  s_last_push_us = static_cast<uint32_t>(esp_timer_get_time() - t0);
  return err;
}

uint32_t last_push_us() { return s_last_push_us; }

}  // namespace lcd
